# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32L1XX_MDP
  c include: .\CMSIS;.\User;.\StdPeriph;.\StdPeriph\inc;.\StdPeriph\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./: startup_stm32l1xx_md.s
  group User
    ./User/: main.c
  group Stdperiph
    ./StdPeriph/src/: stm32l1xx_rcc.c stm32l1xx_gpio.c stm32l1xx_tim.c
  group CMSIS
    ./CMSIS/: system_stm32l1xx.c core_cm3.h
